# Keil uVision project SmartDoorLock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H4K64TLCD Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFF8) CLOCK(45000000)
  output: SmartDoorLock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\APP;..\HAL;..\MT;..\NOTE;..\OS;..\USER
  group User
    ./: STARTUP.A51 main.c
  group HAL
    ../HAL/: HAL_Backlight.c HAL_Task.c HAL_Timer4.c HAL_GPIO.c HAL_TouchKey.c HAL_TFTLCD_SPI.c HAL_DS1302.c HAL_PWMA_horn.c HAL_PWMB_RFID.c HAL_Uart.c HAL_RS485.c HAL_Wiegand.c HAL_Wiegand_Receive.c HAL_LOCK.c HAL_IIC.c
  group MT
    ../MT/: MT_Task.c MT_TK_LED.c MT_TFTLCD.c MT_DS1302.c MT_PWMA_horn.c MT_PWMB_RFID.c MT_ModBus.c MT_IIC_AT24C128.c
  group APP
    ../APP/: APP_Task.c para.c
  group OS
    ../OS/: OS_System.c
  group NOTE
    ../NOTE/: note.c
